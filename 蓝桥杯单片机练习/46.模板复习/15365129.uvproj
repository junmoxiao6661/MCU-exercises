# Keil uVision project 15365129.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 15365129 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: key.c key.h led.c led.h main.c seg.c seg.h uart.c uart.h ultrasound.c ultrasound.h onewire.c ds1302.c iic.c ds1302.h iic.h onewire.h
