# Keil uVision project 2022010519.uvproj, settings and files
target 2022010519 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 2022010519 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\driver
  group user
    ./: main.c
  group driver
    ../driver/: key.c led.c seg.c iic.c
