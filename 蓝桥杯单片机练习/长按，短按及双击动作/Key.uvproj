# Keil uVision project Key.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Key +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 长按，短按及双击动作.c Key.c Led.c
